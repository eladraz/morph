# IAR project PatriotStellaris.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3SxBxx TexasInstruments LM3SxBxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_lm3s9b96; TARGET_IS_FIRESTORM_RA2; STELLARISWARE
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: C:\StellarisWare\boards\dk-lm3s9b96; C:\StellarisWare
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: C:\StellarisWare\boards\dk-lm3s9b96; C:\StellarisWare
  OBJCOPY.OOCOutputFile: PatriotStellaris.bin
  ILINK.IlinkOutputFile: PatriotStellaris.out
  ILINK.IlinkIcfFile: PatriotStellaris.icf
  ILINK.IlinkAdditionalLibs: c:\temp\testclr\output.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    C:/StellarisWare/driverlib/ewarm/Exe/: driverlib.a
    C:/StellarisWare/grlib/ewarm/Exe/: grlib.a
  group Source
    C:/StellarisWare/boards/dk-lm3s9b96/drivers/: kitronix320x240x16_ssd2119_8bit.c set_pinout.c thumbwheel.c thumbwheel.h
    ./: startup_ewarm.c
    ../../../../netcore/wrapper/: wrapper.c wrapper_uix_stellaris.c
